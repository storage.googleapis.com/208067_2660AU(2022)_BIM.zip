Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-05-18T13:25:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 18 13:25:05 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{5EA48043-F0FC-4C4E-B394-5E343577F804}\ifc * Database version: 5507 * Database creation date: Wed May 18 13:25:04 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 18 13:25:05 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 18 13:25:05 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2660AU Shower faucet, 2660AU(2022):2660AU Shower faucet:433579
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - ShowerDefaultElevation: 900 mm
Type - Dimensions - NominalDepth: 144.447 mm; NominalHeight: 120.834 mm; NominalWidth: 214.996 mm
Type - General - Author: BIMStone; BIMObjectName: 2660AU(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/05/2022
Type - Green Building Properties - EAN Number: 6414150099199; EN Standard: EN 817; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822); UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/2660AU; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2660AU; Catalog Drawing URL: http://static.oras.com/catdrw/2660AU; Dimension Drawing URL: http://static.oras.com/dimdrw/2660AU; FDV Document URL: http://www.oras.com/datasheet/2660AU/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2660AU; Group: Shower faucet; Interactive AR View URL: https://static.oras.com/AR/2660AU; Item Type: Sales item; Manufacturer: Oras; Market: International;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2660AU; Model: 2660AU Shower faucet; Name_en: 2660AU Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2660AU; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/2660AU; Product URL: http://static.oras.com/2660AU; Technical DataSheet URL: http://www.oras.com/datasheet/2660AU/en; Type Name: 2660AU Shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Additional Features: protected against back-flow in domestic use (according to DIN EN 1717); Advanced Features: Inner body made of DZR brass; Backflow Prevention EN1717: AA; Connection: Eccentric coupling(s);Cover plate(s); Connection Size: G3/4; Flow Rate At 300kPa: 0.00918181 m3/s; Installation Type: Wall mounted; Installation Width: CC150± 15 mm; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2660AU(2022); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2660AU; Name: 2660AU Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 215x145x120 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2660AU; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2660AU Shower faucet
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0781202 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0037826 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2660AU(2022): 2660AU Shower faucet; Family and Type: 2660AU(2022): 2660AU Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2660AU(2022): 2660AU Shower faucet; Type Id: 2660AU(2022): 2660AU Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
